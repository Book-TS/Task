<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\2_Channel_Uart_MSP430.ewp</path>
    </project>
    <batchBuild />
</workspace>
